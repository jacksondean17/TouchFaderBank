# Keil uVision project FaderBankv1.uvprojx, settings and files
target FaderBankv1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F072RBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: FaderBankv1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F072xB
  c include: ../TOUCHSENSING/App;../USB_DEVICE/App;../USB_DEVICE/Target;../Core/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_TouchSensing_Library/inc;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/MIDI/Inc;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f072xb.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f0xx_it.c stm32f0xx_hal_msp.c fader_bank.c IS31FL3236A_led_driver.c
  group Application/User/TOUCHSENSING/App
    ../TOUCHSENSING/App/: touchsensing.c tsl_user.c stmCriticalSection.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_ll_usb.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_exti.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_tsc.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_pcd.c stm32f0xx_hal_pcd_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f0xx.c
  group Middlewares/TouchSensing
    ../Middlewares/ST/STM32_TouchSensing_Library/src/: tsl.c tsl_acq_tsc.c tsl_globals.c tsl_touchkey.c tsl_acq.c tsl_dxs.c tsl_linrot.c tsl_ecs.c tsl_object.c tsl_time.c tsl_filter.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_midi_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Class/MIDI/Src/: usbd_midi.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
software components: CMSIS:CORE 4.3.0
